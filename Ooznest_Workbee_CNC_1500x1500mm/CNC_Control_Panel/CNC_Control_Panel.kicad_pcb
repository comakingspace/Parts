# Repository comakingspace/Parts

File README.md:

# Parts
All upgrade/replacement part files for our machines and tools.

## KiCad design Ooznest_Workbee_CNC_1500x1500mm/CNC_Control_Panel/CNC_Control_Panel.kicad_pcb

Parts:
$H_HOME1: SW_Push; SW_PUSH_6mm
$X_UNLOCK1: SW_Push; SW_PUSH_6mm
C-CTRL_RESET1: SW_Push; SW_PUSH_6mm
D1: 1N4148W; D_SOD-123
J1, J3: Conn_01x07_Male; PinHeader_1x07_P2.54mm_Horizontal
J2: Conn_01x03_Male; PinHeader_1x03_P2.54mm_Horizontal
MK1, MK2, MK3, MK4: M2.5; MountingHole_2.7mm_M2.5
ON_OFF1: SW_Push; SW_PUSH_6mm
P1: Conn_02x20_Odd_Even; PinSocket_2x20_P2.54mm_Vertical
PAUSE_RESUME1: SW_Push; SW_PUSH_6mm
Q1: BSS138; SOT-23
R1, R2, R3, R4, R5, R6, R7, R8, R9, R10, R11, R12, R13, R14, R15, R16, R17, R18, R19, R20, R21, R22: 10k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
X0: SW_Push; SW_PUSH_6mm
X-DECR1: SW_Push; SW_PUSH_6mm
X-INCR1: SW_Push; SW_PUSH_6mm
Y0: SW_Push; SW_PUSH_6mm
Y-DECR1: SW_Push; SW_PUSH_6mm
Y-INCR1: SW_Push; SW_PUSH_6mm
Z0: SW_Push; SW_PUSH_6mm
Z-DECR1: SW_Push; SW_PUSH_6mm
Z-INCR1: SW_Push; SW_PUSH_6mm

Connections:
+3V3: J3.2, P1.1, P1.17, Q1.1 (G), R1.1, R2.1, R3.1, R4.1, R5.1, R6.1, R7.1, R8.1, R9.1, R10.1, R11.1, R12.1, R13.1, R14.1, R15.1, R16.1, R17.1, R18.1, R19.1, R20.1, R21.1
+5V: J2.3, J3.1, P1.2, P1.4, R22.1
/GPIO2(SDA1): J3.5, P1.3
/GPIO3(SCL1): D1.2 (A), J3.6, P1.5
/GPIO4(GCLK): P1.7, PAUSE_RESUME1.1, R2.2
/GPIO5: J1.3, P1.29, R15.2
/GPIO6: J1.4, P1.31, R16.2
/GPIO7(SPI1_CE_N): P1.26, R18.2, Z-DECR1.1
/GPIO8(SPI0_CE_N): P1.24, R19.2, Z-INCR1.1
/GPIO9(SPI0_MISO): J1.1, P1.21, R13.2
/GPIO10(SPI0_MOSI): P1.19, R6.2, Z0.1
/GPIO11(SPI0_SCK): J1.2, P1.23, R14.2
/GPIO12(PWM0): P1.32, Q1.2 (S), R1.2
/GPIO13(PWM1): P1.33
/GPIO14(TXD0): J3.3, P1.8
/GPIO15(RXD0): J3.4, P1.10
/GPIO16: C-CTRL_RESET1.1, P1.36, R5.2
/GPIO17(GEN0): D1.1 (K), ON_OFF1.1, P1.11, R9.2
/GPIO18(GEN1)(PWM0): P1.12, R12.2, Y-INCR1.1
/GPIO19(SPI1_MISO): J1.5, P1.35, R17.2
/GPIO20(SPI1_MOSI): $X_UNLOCK1.1, P1.38, R4.2
/GPIO21(SPI1_SCK): $H_HOME1.1, P1.40, R3.2
/GPIO22(GEN3): P1.15, R7.2, Y0.1
/GPIO23(GEN4): P1.16, R11.2, Y-DECR1.1
/GPIO24(GEN5): P1.18, R21.2, X-INCR1.2
/GPIO25(GEN6): P1.22, R10.2, X-DECR1.1
/GPIO26: J1.6, P1.37, R20.2
/GPIO27(GEN2): P1.13, R8.2, X0.1
/ID_SC: P1.28
/ID_SD: P1.27
GND: $H_HOME1.2, $X_UNLOCK1.2, C-CTRL_RESET1.2, J1.7, J2.1, J3.7, ON_OFF1.2, P1.6, P1.9, P1.14, P1.20, P1.25, P1.30, P1.34, P1.39, PAUSE_RESUME1.2, X0.2, X-DECR1.2, X-INCR1.1, Y0.2, Y-DECR1.2, Y-INCR1.2, Z0.2, Z-DECR1.2, Z-INCR1.2
unnamed: J2.2, Q1.3 (D), R22.2

Notes on the sheet:
ID_SD and ID_SC PINS: These pins are reserved for HAT ID EEPROM. At boot time this I2C interface will be interrogated to look for an EEPROM that identifes the attached board and allows automagic setup of the GPIOs (and optionally, Linux drivers). DO NOT USE these pins for anything other than attach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
Mounting Holes
Function Buttons
LED Indicator (WS2812B)
Rotatry Switch
Directional Control
GPIO3 boots Pi when pulled down via On/Off button. Diode to avoid I2C triggering the shutdown.

Board: 2 copper layers, 100.0 x 100.0 mm, 46 parts (4 on the bottom side), 29 nets.

## Commit log (part)

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2021-11-07 added Hole cutting jig for Makita router
2021-11-07 Dübelfräse Staubabsaugung
2021-11-07 gitignore
2021-11-07 Scheppach Ständerbohrmaschine
2022-08-12 added Festool Adapter for Bosch GEX 40-150
2022-08-12 filename
2023-05-13 added a temp folder; will clean up
2023-05-25 Rename temp dir
2023-05-25 Add shorter Bandsaw Adapter
    The shop vac actually needs the teeth to be at 57 mm from the bottom.
2023-05-26 Added Makita_DRT50RTJX2_Festool_Adapter
2023-05-26 added Bosch_PST_750_PE_Festool_Adapter
2023-05-26 added Holzmann BT 203-914_Disk_Festool_Adapter
2023-05-26 added Metabo_BS_1638_W_Festool_Adapter
2023-05-26 added Westfalia_Universal_Frästisch_Nr645697_Festool_Adapter
2023-05-26 added Proxxon_DSH_Festool_Adapter
2023-05-26 removed temp folder
2024-01-19 added router table parts
2024-01-19 router table naming convention
2025-02-20 new version of Bosch Sander Festool adapter added
2025-02-20 Added wall holder
2025-04-09 added: thing to push saw with butt
    Words have never been put into a sentence in this order before...
2025-09-18 Add files via upload
    Leo rocks
2025-09-18 git is hard
2025-10-23 Add files via upload
    3D printable hex key (5 mm) for the Sauter OFL 2.0 adjustment screws
2025-10-23 Add files via upload
    v2
2025-12-24 Rename folder to 65415..
2025-12-24 Move files to 65415 folder..
2026-04-15 Added Altendorf Stopper files (not yet tested)
2026-05-22 Add files via upload
    https://wiki.comakingspace.de/Project:Grill_Knob
